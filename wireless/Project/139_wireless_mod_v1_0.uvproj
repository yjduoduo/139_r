# Keil uVision project 139_wireless_mod_v1_0.uvproj, settings and files
target 139_wireless_mod (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 139_wireless_mod_v1_0
  c flags: Optim=1
  c include: ../api;../board;../common;../cpu;../doc;../drivers;../drivers/i2c;../drivers/input;../drivers/rtc;../drivers/serial;../drivers/spi;../drivers/timer;../include;../include/system;../lib_arm;../include/drivers;../include/common;../board/init_139;../common/font
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group start
    ./: startup_LPC17xx.s
  group include
    ../include/: type.h includeall.h inc_for_src.h
    ../include/system/: LPC17xx.h lpc17xx_uart.h system_LPC17xx.h
    ../include/drivers/: delay.h extint.h gpio.h i2c.h lcd_printf.h pwm.h ssp.h timer_all.h uart0.h uart1.h pcf8563.h led.h relay.h lcd12864.h
    ../include/common/: timedef.h
  group src
    ../src/: main.c
  group common
    ../common/system/: system_LPC17xx.c
    ../common/timedef/: timedef.c
    ../common/font/: ziku.h
  group printf
    ../common/printf/: lcd_printf.c
  group drivers
    ../drivers/serial/: uart_all.c uart0.c uart1.c
    ../drivers/delay/: delay.c
    ../drivers/timer/: timer_all.c
    ../drivers/i2c/: i2c.c
    ../drivers/gpio/: gpio.c
    ../drivers/ssp/: ssp.c
    ../drivers/rtc/: pcf8563.c
    ../drivers/led/: led.c
    ../drivers/pwm/: pwm.c
    ../drivers/relay/: relay.c
    ../drivers/lcd12864/: lcd12864.c
    ../drivers/extint/: extint.c
  group board
    ../board/init_139/: init.c
